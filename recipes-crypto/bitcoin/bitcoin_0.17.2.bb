require bitcoin.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=ef10a664e5e37e64d992444b7b4d0121"
SRC_URI = "git://github.com/bitcoin/bitcoin.git;protocol=git;tag=v${PV};nobranch=1"