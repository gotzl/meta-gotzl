inherit pypi setuptools3
require recipes-devtools/python/python-urllib3.inc

LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=ea114851ad9a8c311aac8728a681a067"

SRC_URI[md5sum] = "1ad43e4b5ab7a0794c89dc057e1d7179"
SRC_URI[sha256sum] = "a68ac5e15e76e7e5dd2b8f94007233e01effe3e50e8daddf69acfd81cb686baf"
