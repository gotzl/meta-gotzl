inherit setuptools3
require recipes-devtools/python/python-requests.inc

LIC_FILES_CHKSUM = "file://LICENSE;md5=bfbeafb85a2cee261510d65d5ec19156"

SRC_URI[md5sum] = "6c1a31afec9d614e2e71a91ee6ca2878"
SRC_URI[sha256sum] = "ec22d826a36ed72a7358ff3fe56cbd4ba69dd7a6718ffd450ff0e9df7a47ce6a"
