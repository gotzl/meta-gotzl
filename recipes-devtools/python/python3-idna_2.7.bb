inherit pypi setuptools3
require recipes-devtools/python/python-idna.inc

SRC_URI[md5sum] = "0e5bb69018ddef1b9d95f681182be82c"
SRC_URI[sha256sum] = "684a38a6f903c1d71d6d5fac066b58d7768af4de2b832e426ec79c30daa94a16"
